# Keil uVision project usbd_dfu.uvprojx, settings and files
target USBD_DFU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F150R8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DFU +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c misc: --c99
  c include: ..\..\..\..\src\CMSIS\GD\GD32F1x0\Include;..\..\..\..\src\GD32F1x0_standard_peripheral\Include;..\..\..\..\src\GD32F1x0_usbd_driver\Include;..\inc;..\..\..\..\src\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../src/: main.c gd32f1x0_it.c dfu_core.c systick.c
  group CMSIS
    ../../../../src/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group GD32F1x0_Peripherals
    ../../../../src/GD32F1x0_standard_peripheral/Source/: gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_syscfg.c gd32f1x0_rcu.c gd32f1x0_pmu.c gd32f1x0_misc.c gd32f1x0_gpio.c gd32f1x0_usart.c
  group GD32F1x0_EVAL
    ../../../../src/Utilities/: gd32f1x0_eval.c
  group USBD_Drivers
    ../../../../src/GD32F1x0_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
  group Startup
    ../../../../src/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
software components: CMSIS:CORE 5.4.0
