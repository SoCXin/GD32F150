# IAR project audio.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F150x8 GD GD32F150x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F130_150
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\src\CMSIS\GD\GD32F1x0\Include; ..\..\..\..\src\GD32F1x0_standard_peripheral\Include; ..\..\..\..\src\GD32F1x0_usbd_driver\Include; ..\..\..\..\src\Utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: CDC_ACM.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F150x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appliction
    ../src/: audio_core.c gd32f1x0_it.c main.c usbd_audio_out_if.c
  group CMSIS
    ../../../../src/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group Doc
    ../: readme.txt
  group GD32F150R_EVAL
    ../../../../src/Utilities/: gd32f150r_audio_codec.c gd32f1x0_eval.c
  group GD32F1x0_Peripherals
    ../../../../src/GD32F1x0_standard_peripheral/Source/: gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_gpio.c gd32f1x0_misc.c gd32f1x0_rcu.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_usart.c
  group Startup
    ../../../../src/CMSIS/GD/GD32F1x0/Source/IAR/: startup_gd32f1x0.s
  group USB_Driver
    ../../../../src/GD32F1x0_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
