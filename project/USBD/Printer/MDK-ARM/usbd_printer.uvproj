# Keil uVision project usbd_printer.uvproj, settings and files
target USBD_Printer (ARM-ADS)
  device: GD32F150R8 GigaDevice
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USBD_Printer +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c misc: --c99
  c include: ..\..\..\..\src\CMSIS\GD\GD32F1x0\Include;..\..\..\..\src\GD32F1x0_standard_peripheral\Include;..\..\..\..\src\GD32F1x0_usbd_driver\Include;..\inc;..\..\..\..\src\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../src/: main.c gd32f1x0_it.c printer_core.c
  group CMSIS
    ../../../../src/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group GD32F1x0_Peripherals
    ../../../../src/GD32F1x0_standard_peripheral/Source/: gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_syscfg.c gd32f1x0_rcu.c gd32f1x0_pmu.c gd32f1x0_misc.c gd32f1x0_gpio.c gd32f1x0_usart.c
  group GD32F1x0_EVAL
    ../../../../src/Utilities/: gd32f1x0_eval.c
  group USBD_Drivers
    ../../../../src/GD32F1x0_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
  group Startup
    ../../../../src/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
  group Doc
    ../: readme.txt
