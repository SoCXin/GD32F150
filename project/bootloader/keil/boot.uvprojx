# Keil uVision project boot.uvprojx, settings and files
target GD32F1x0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F130C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x02000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./output/project.bin ./output/Project.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c include: ..\;..\..\Firmware\Peripherals\inc;..\..\Firmware\CMSIS;..\..\Utilities;..\UART;..\FMC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6400
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../Firmware/CMSIS/: system_gd32f1x0.c
  group Startup
    ../../Firmware/CMSIS/ARM/: startup_gd32f1x0.s
  group GD32F1x0_Peripherals
    ../../Firmware/Peripherals/src/: gd32f1x0_adc.c gd32f1x0_cec.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_exti.c gd32f1x0_gpio.c gd32f1x0_iwdg.c gd32f1x0_mcudbg.c gd32f1x0_misc.c gd32f1x0_rcc.c gd32f1x0_rtc.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_wwdg.c gd32f1x0_usart.c gd32f1x0_ivref.c gd32f1x0_opamp.c gd32f1x0_can.c gd32f1x0_cmp.c gd32f1x0_dma.c gd32f1x0_fmc.c gd32f1x0_i2c.c gd32f1x0_pwr.c gd32f1x0_spi.c
  group Application
    ../: main.c gd32f1x0_it.c simplequeue.c util.c
  group UART
    ../UART/: usart.c
  group FMC
    ../FMC/: fmc.c
